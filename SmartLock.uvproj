# Keil uVision project SmartLock.uvproj, settings and files
target SmartLock (ARM-ADS)
  device: HT32F52354 Holtek
  pack: Holtek.HT32_DFP.1.0.16
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x00000000-0x0001FBFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: SmartLock +hex
  AfterMake: fromelf --bin -o #L.bin #L
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52354_SK, USE_HT32F52344_54, USE_MEM_HT32F52354
  c include: ..\;.\Library\CMSIS\Include;.\Library\Device\Holtek\HT32F5xxxx\Include;.\Library\HT32F5xxxx_Driver\inc;.\Library\HT32_USBD_Library\inc;.\Utilities;.\Inc;.\Config
  asm define: USE_HT32_CHIP=9
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./User/: ht32f5xxxx_01_it.c main.c
  group Src
    ./Src/: admin.c buzzer.c card.c card_spi.c delay.c key_iic.c motor.c oled.c oled_app.c password.c rtc.c touchkey.c system_config.c
  group Library
    ./Library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32_retarget.c ht32_serial.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_div.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group Config
    ./Config/: ht32_op.s ht32f5xxxx_01_usbdconf.h ht32f5xxxx_conf.h
  group CMSIS
    ./Library/Device/Holtek/HT32F5xxxx/Source/: system_ht32f5xxxx_03.c
  group MDK-ARM
    ./Library/Device/Holtek/HT32F5xxxx/Source/ARM/: startup_ht32f5xxxx_01.s
  group USBD_Library
    ./Library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Utilities
    ./Utilities/: ht32_board.c
